Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-02-28T13:38:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Feb 28 13:38:29 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\940a41ee-d9d3-4edb-9d42-76dcb64b0e35\06342b27-d3ee-4b78-a8e5-c3179037ce11\ifc * Database version: 5507 * Database creation date: Mon Feb 28 13:38:29 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Feb 28 13:38:29 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Feb 28 13:38:29 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11749930_CN_KFNS7795DC:38779502_CN_11749930_KFNS7795DC, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 38779502_CN_11749930_KFNS7795DC
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_QuantityTakeOff - Reference: 38779502_CN_11749930_KFNS7795DC
Type - Pset_ProvisionForVoid - Width: 559 mm; Height: 1770 mm; Depth: 546 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Zinc_Steel, z_Miele_Design_BRWS, z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_Glass
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment

# IfcDistributionPort, Port_353816
Description: Flow; FlowDirection: SOURCEANDSINK
